Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-07-05T14:48:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternativ-UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 05 14:48:13 2022 * Host: ENA567 * Database: C:\Users\admin\AppData\Local\Temp\{04DCD179-115F-47FA-99FB-BCC34264B33F}\ifc * Database version: 5507 * Database creation date: Tue Jul 05 14:48:13 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 05 14:48:13 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 05 14:48:13 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingStorey, Ebene -1
LongName: Ebene -1; Elevation: -3 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Grafiken(Type) - Farbe: 16728128; Linienmuster: (Ebene); Linienstärke: 1; Symbol: Beschriftung Ebene Oberkante: Allgemein; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Abhängigkeiten - Ansicht: -3 m
Abmessungen - Höhe für Berechnung: 1 m
Daten - FM Geschoss: UG 1
ID-Daten - Gebäudegeschoss: no; Name: Ebene -1; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene

# IfcFlowTerminal: Cetus-L120-3-B, Cetus-L120-3-B (DEU):Cetus-L120-3-B:2429955
In: Ebene -1
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - Abmessungen - Lampenlänge: 1.2 m; Leuchtenbreite: 0.055 m; Symbolbreite: 0.0011 m; Symbollänge: 0.024 m; Symbolskala: 0.05 m
Type - Elektro - ADSK_Anzahl der Phasen: 1; ADSK_Anzahl der Phasen numerisch: 1; ADSK_Lastklassifizierung: Beleuchtung; ADSK_Leistungsfaktor: 0.95; ADSK_Scheinleistung: 27.6842 W; ADSK_Spannung: 230 V; ADSK_Strom: 0.120366 A; ADSK_Wattzahl: 26.3 W
Type - Elektrotechnik - Spannungsversorgung: 230 V
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 3000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 27.4101 lx; Datei für fotometrisches Netz: cetus-L120-3-B_LDT.ies; Emissionsform beim Rendern sichtbar: no; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Rechteck+Fotometrisches Netz; Lichtstärke: 254.648 cd; Lichtstrom: 3200 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Neigungswinkel: 90 deg; Von Breite des Rechtecks ausssenden: 0.055 m; Von Länge des Rechtecks aussenden: 1.197 m; Wattzahl: 21.5427 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Hersteller: SWISSLUX; Typname: Cetus-L120-3-B; URL: https://www.swisslux.ch/r/YjE
Type - Sonstige - Kategorie: Leuchten; Anschlussart: Schraubklemme; Ansprechhelligkeit einstellbar: ja; Artikelnummer: 161988; Betriebsgerät: LED Betriebsgerät; Effizienz ab Diffusor [lm/W]: 82,489; Eingang 1: Tastereingang / Slaveeingang; Eingang 2: Tastereingang / Slaveeingang; Einsatzgebiet: Innenraum; Energieeffizienzklasse Leuchte/System nach Energieetikette 2021: G; Energieeffizienzklasse Leuchtmittel nach Energieetikette 2021: C; E-NR: 941404349; Erfassungsbereich [°]: 360; Familienname: Cetus-L120-3-B (DEU); Farbkonsistenz in MacAdam-Ellipsen [SDCM]: 3; Farbtemperatur [K]: 3000; Farbwiedergabe-Index (CRI): >85; Fernbedienbar: Fernbedienbar über IR-Bluetooth Dongle (IR-Connect), mit Swisslux App (iOS, Android); Flimmer-Messgrösse: NA; Garantie [j]: 5; Garantie auf Akku [j]: 0; Geeignet für Anbaumontage: ja; Geeignet für Deckenmontage: ja; Geeignet für drahlose Übertragung: Ja; Geeignet für Notlicht: ja; Geeignet für Wandmontage: ja; Gehäusefarbe: weiss; Lebensdauer L70B10 bei 25°C [h]: 50000; Leistungsaufnahme 1000 h [kW/h]: 26.3; Leuchtmittel: LED; Lichtanteil direkt-indirekt: 82% / 18%; Lichtaustritt: direkt; Lichtstrom ab Diffusor [lm]: 1886,5; Lichtstrom bei Notlicht ab Diffusor [lm]: 200; Maximale Anzahl Leuchten an Leitungsschutzschalter: LS 10 A (B): 18 Stk.; Maximale Anzahl Leuchten an Leitungsschutzschalter: LS 16 A (B): 30 Stk.; Maximale Länge Datendraht «D» [km]: 1; Messgrösse für Stroboskop-Effekte: NA; Mit Betriebsgerät: ja; Mit Bewegungsmelder: ja; Mit Leuchtmittel: ja; Mit Lichtsensor: ja; Montagehöhe empfohlen [m]: 2,5-3; Montagehöhe maximum [m]: 10; Montagehöhe minimum [m]: 2; Montagekategorie: Decken-Anbau; Nennleistung [W]: 26.3 W; Netzfrequenz [Hz]: 50-60; Notlicht: mit 230 V DC; Oberflächenschutz Gehäuse: verzinkt; Prüfzeichen: CE; Reichweite beidirektem Draufzugehen [m]: 1.5; Reichweite bei seitlichem Vorbeigehen [m]: 5; Reichweite für sitzende Personen (Präsenz) [m]: 1.5; Schutzart [IP]: 30; Schutzklasse: I; Spannungsart: AC; Standbyleistung [W]: 1.156; Steuerelemente: TRIVALITE; UV-Beständig: Ja; Werksprogramm: Ja
Pset_ManufacturerTypeInformation - Manufacturer: SWISSLUX
Pset_DistributionFlowElementCommon - Reference: Cetus-L120-3-B
Abhängigkeiten - Arbeitsebene: Basisdecke : Standard; Ebene: Ebene: Ebene -1; Versatz: 0 m
Abmessungen - Durchmesser der leerrohr: 0.02 m; Volumen: 0.00527868 m3
Elektro - Stromkreise - Elektrische Daten: 230 V/1-28 VA
ID-Daten - Kennzeichen: 4
Phasen - Phase erstellt: Phase 1
Sonstige - Bauteillistenebene: Ebene: Ebene -1; Familie: Cetus-L120-3-B (DEU): Cetus-L120-3-B; Familie und Typ: Cetus-L120-3-B (DEU): Cetus-L120-3-B; Typ: Cetus-L120-3-B (DEU): Cetus-L120-3-B; Typ-ID: Cetus-L120-3-B (DEU): Cetus-L120-3-B
